/*
 * PSpectro.cpp
 * --------------------------------------------------------------------------
 * Implementacion. Ver PSpectro.h para la documentacion de uso.
 * --------------------------------------------------------------------------
 */

#include "calculoColorimetria.h"
#include <math.h>

// ====== Generado automáticamente desde colour-science (CIE 15:2004 datasets) ======
// Rango: 380-780nm, paso 5nm, 81 puntos

static const float CMF_XBAR[81] = {0.001368, 0.002236, 0.004243, 0.007650, 0.014310, 0.023190, 0.043510, 0.077630, 0.134380, 0.214770, 0.283900, 0.328500, 0.348280, 0.348060, 0.336200, 0.318700, 0.290800, 0.251100, 0.195360, 0.142100, 0.095640, 0.057950, 0.032010, 0.014700, 0.004900, 0.002400, 0.009300, 0.029100, 0.063270, 0.109600, 0.165500, 0.225750, 0.290400, 0.359700, 0.433450, 0.512050, 0.594500, 0.678400, 0.762100, 0.842500, 0.916300, 0.978600, 1.026300, 1.056700, 1.062200, 1.045600, 1.002600, 0.938400, 0.854450, 0.751400, 0.642400, 0.541900, 0.447900, 0.360800, 0.283500, 0.218700, 0.164900, 0.121200, 0.087400, 0.063600, 0.046770, 0.032900, 0.022700, 0.015840, 0.011359, 0.008111, 0.005790, 0.004109, 0.002899, 0.002049, 0.001440, 0.001000, 0.000690, 0.000476, 0.000332, 0.000235, 0.000166, 0.000117, 0.000083, 0.000059, 0.000042};

static const float CMF_YBAR[81] = {0.000039, 0.000064, 0.000120, 0.000217, 0.000396, 0.000640, 0.001210, 0.002180, 0.004000, 0.007300, 0.011600, 0.016840, 0.023000, 0.029800, 0.038000, 0.048000, 0.060000, 0.073900, 0.090980, 0.112600, 0.139020, 0.169300, 0.208020, 0.258600, 0.323000, 0.407300, 0.503000, 0.608200, 0.710000, 0.793200, 0.862000, 0.914850, 0.954000, 0.980300, 0.994950, 1.000000, 0.995000, 0.978600, 0.952000, 0.915400, 0.870000, 0.816300, 0.757000, 0.694900, 0.631000, 0.566800, 0.503000, 0.441200, 0.381000, 0.321000, 0.265000, 0.217000, 0.175000, 0.138200, 0.107000, 0.081600, 0.061000, 0.044580, 0.032000, 0.023200, 0.017000, 0.011920, 0.008210, 0.005723, 0.004102, 0.002929, 0.002091, 0.001484, 0.001047, 0.000740, 0.000520, 0.000361, 0.000249, 0.000172, 0.000120, 0.000085, 0.000060, 0.000042, 0.000030, 0.000021, 0.000015};

static const float CMF_ZBAR[81] = {0.006450, 0.010550, 0.020050, 0.036210, 0.067850, 0.110200, 0.207400, 0.371300, 0.645600, 1.039050, 1.385600, 1.622960, 1.747060, 1.782600, 1.772110, 1.744100, 1.669200, 1.528100, 1.287640, 1.041900, 0.812950, 0.616200, 0.465180, 0.353300, 0.272000, 0.212300, 0.158200, 0.111700, 0.078250, 0.057250, 0.042160, 0.029840, 0.020300, 0.013400, 0.008750, 0.005750, 0.003900, 0.002750, 0.002100, 0.001800, 0.001650, 0.001400, 0.001100, 0.001000, 0.000800, 0.000600, 0.000340, 0.000240, 0.000190, 0.000100, 0.000050, 0.000030, 0.000020, 0.000010, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000, 0.000000};


static const float TCS_TCS01[81] = {0.219000, 0.239000, 0.252000, 0.256000, 0.256000, 0.254000, 0.252000, 0.248000, 0.244000, 0.240000, 0.237000, 0.232000, 0.230000, 0.226000, 0.225000, 0.222000, 0.220000, 0.218000, 0.216000, 0.214000, 0.214000, 0.214000, 0.216000, 0.218000, 0.223000, 0.225000, 0.226000, 0.226000, 0.225000, 0.225000, 0.227000, 0.230000, 0.236000, 0.245000, 0.253000, 0.262000, 0.272000, 0.283000, 0.298000, 0.318000, 0.341000, 0.367000, 0.390000, 0.409000, 0.424000, 0.435000, 0.442000, 0.448000, 0.450000, 0.451000, 0.451000, 0.451000, 0.451000, 0.451000, 0.450000, 0.450000, 0.451000, 0.451000, 0.453000, 0.454000, 0.455000, 0.457000, 0.458000, 0.460000, 0.462000, 0.463000, 0.464000, 0.465000, 0.466000, 0.466000, 0.466000, 0.466000, 0.467000, 0.467000, 0.467000, 0.467000, 0.467000, 0.467000, 0.467000, 0.467000, 0.467000};

static const float TCS_TCS02[81] = {0.070000, 0.079000, 0.089000, 0.101000, 0.111000, 0.116000, 0.118000, 0.120000, 0.121000, 0.122000, 0.122000, 0.122000, 0.123000, 0.124000, 0.127000, 0.128000, 0.131000, 0.134000, 0.138000, 0.143000, 0.150000, 0.159000, 0.174000, 0.190000, 0.207000, 0.225000, 0.242000, 0.253000, 0.260000, 0.264000, 0.267000, 0.269000, 0.272000, 0.276000, 0.282000, 0.289000, 0.299000, 0.309000, 0.322000, 0.329000, 0.335000, 0.339000, 0.341000, 0.341000, 0.342000, 0.342000, 0.342000, 0.341000, 0.341000, 0.339000, 0.339000, 0.338000, 0.338000, 0.337000, 0.336000, 0.335000, 0.334000, 0.332000, 0.332000, 0.331000, 0.331000, 0.330000, 0.329000, 0.328000, 0.328000, 0.327000, 0.326000, 0.325000, 0.324000, 0.324000, 0.324000, 0.323000, 0.322000, 0.321000, 0.320000, 0.318000, 0.316000, 0.315000, 0.315000, 0.314000, 0.314000};

static const float TCS_TCS03[81] = {0.065000, 0.068000, 0.070000, 0.072000, 0.073000, 0.073000, 0.074000, 0.074000, 0.074000, 0.073000, 0.073000, 0.073000, 0.073000, 0.073000, 0.074000, 0.075000, 0.077000, 0.080000, 0.085000, 0.094000, 0.109000, 0.126000, 0.148000, 0.172000, 0.198000, 0.221000, 0.241000, 0.260000, 0.278000, 0.302000, 0.339000, 0.370000, 0.392000, 0.399000, 0.400000, 0.393000, 0.380000, 0.365000, 0.349000, 0.332000, 0.315000, 0.299000, 0.285000, 0.272000, 0.264000, 0.257000, 0.252000, 0.247000, 0.241000, 0.235000, 0.229000, 0.224000, 0.220000, 0.217000, 0.216000, 0.216000, 0.219000, 0.224000, 0.230000, 0.238000, 0.251000, 0.269000, 0.288000, 0.312000, 0.340000, 0.366000, 0.390000, 0.412000, 0.431000, 0.447000, 0.460000, 0.472000, 0.481000, 0.488000, 0.493000, 0.497000, 0.500000, 0.502000, 0.505000, 0.510000, 0.516000};

static const float TCS_TCS04[81] = {0.074000, 0.083000, 0.093000, 0.105000, 0.116000, 0.121000, 0.124000, 0.126000, 0.128000, 0.131000, 0.135000, 0.139000, 0.144000, 0.151000, 0.161000, 0.172000, 0.186000, 0.205000, 0.229000, 0.254000, 0.281000, 0.308000, 0.332000, 0.352000, 0.370000, 0.383000, 0.390000, 0.394000, 0.395000, 0.392000, 0.385000, 0.377000, 0.367000, 0.354000, 0.341000, 0.327000, 0.312000, 0.296000, 0.280000, 0.263000, 0.247000, 0.229000, 0.214000, 0.198000, 0.185000, 0.175000, 0.169000, 0.164000, 0.160000, 0.156000, 0.154000, 0.152000, 0.151000, 0.149000, 0.148000, 0.148000, 0.148000, 0.149000, 0.151000, 0.154000, 0.158000, 0.162000, 0.165000, 0.168000, 0.170000, 0.171000, 0.170000, 0.168000, 0.166000, 0.164000, 0.164000, 0.165000, 0.168000, 0.172000, 0.177000, 0.181000, 0.185000, 0.189000, 0.192000, 0.194000, 0.197000};

static const float TCS_TCS05[81] = {0.295000, 0.306000, 0.310000, 0.312000, 0.313000, 0.315000, 0.319000, 0.322000, 0.326000, 0.330000, 0.334000, 0.339000, 0.346000, 0.352000, 0.360000, 0.369000, 0.381000, 0.394000, 0.403000, 0.410000, 0.415000, 0.418000, 0.419000, 0.417000, 0.413000, 0.409000, 0.403000, 0.396000, 0.389000, 0.381000, 0.372000, 0.363000, 0.353000, 0.342000, 0.331000, 0.320000, 0.308000, 0.296000, 0.284000, 0.271000, 0.260000, 0.247000, 0.232000, 0.220000, 0.210000, 0.200000, 0.194000, 0.189000, 0.185000, 0.183000, 0.180000, 0.177000, 0.176000, 0.175000, 0.175000, 0.175000, 0.175000, 0.177000, 0.180000, 0.183000, 0.186000, 0.189000, 0.192000, 0.195000, 0.199000, 0.200000, 0.199000, 0.198000, 0.196000, 0.195000, 0.195000, 0.196000, 0.197000, 0.200000, 0.203000, 0.205000, 0.208000, 0.212000, 0.215000, 0.217000, 0.219000};

static const float TCS_TCS06[81] = {0.151000, 0.203000, 0.265000, 0.339000, 0.410000, 0.464000, 0.492000, 0.508000, 0.517000, 0.524000, 0.531000, 0.538000, 0.544000, 0.551000, 0.556000, 0.556000, 0.554000, 0.549000, 0.541000, 0.531000, 0.519000, 0.504000, 0.488000, 0.469000, 0.450000, 0.431000, 0.414000, 0.395000, 0.377000, 0.358000, 0.341000, 0.325000, 0.309000, 0.293000, 0.279000, 0.265000, 0.253000, 0.241000, 0.234000, 0.227000, 0.225000, 0.222000, 0.221000, 0.220000, 0.220000, 0.220000, 0.220000, 0.220000, 0.223000, 0.227000, 0.233000, 0.239000, 0.244000, 0.251000, 0.258000, 0.263000, 0.268000, 0.273000, 0.278000, 0.281000, 0.283000, 0.286000, 0.291000, 0.296000, 0.302000, 0.313000, 0.325000, 0.338000, 0.351000, 0.364000, 0.376000, 0.389000, 0.401000, 0.413000, 0.425000, 0.436000, 0.447000, 0.458000, 0.469000, 0.477000, 0.485000};

static const float TCS_TCS07[81] = {0.378000, 0.459000, 0.524000, 0.546000, 0.551000, 0.555000, 0.559000, 0.560000, 0.561000, 0.558000, 0.556000, 0.551000, 0.544000, 0.535000, 0.522000, 0.506000, 0.488000, 0.469000, 0.448000, 0.429000, 0.408000, 0.385000, 0.363000, 0.341000, 0.324000, 0.311000, 0.301000, 0.291000, 0.283000, 0.273000, 0.265000, 0.260000, 0.257000, 0.257000, 0.259000, 0.260000, 0.260000, 0.258000, 0.256000, 0.254000, 0.254000, 0.259000, 0.270000, 0.284000, 0.302000, 0.324000, 0.344000, 0.362000, 0.377000, 0.389000, 0.400000, 0.410000, 0.420000, 0.429000, 0.438000, 0.445000, 0.452000, 0.457000, 0.462000, 0.466000, 0.468000, 0.470000, 0.473000, 0.477000, 0.483000, 0.489000, 0.496000, 0.503000, 0.511000, 0.518000, 0.525000, 0.532000, 0.539000, 0.546000, 0.553000, 0.559000, 0.565000, 0.570000, 0.575000, 0.578000, 0.581000};

static const float TCS_TCS08[81] = {0.104000, 0.129000, 0.170000, 0.240000, 0.319000, 0.416000, 0.462000, 0.482000, 0.490000, 0.488000, 0.482000, 0.473000, 0.462000, 0.450000, 0.439000, 0.426000, 0.413000, 0.397000, 0.382000, 0.366000, 0.352000, 0.337000, 0.325000, 0.310000, 0.299000, 0.289000, 0.283000, 0.276000, 0.270000, 0.262000, 0.256000, 0.251000, 0.250000, 0.251000, 0.254000, 0.258000, 0.264000, 0.269000, 0.272000, 0.274000, 0.278000, 0.284000, 0.295000, 0.316000, 0.348000, 0.384000, 0.434000, 0.482000, 0.528000, 0.568000, 0.604000, 0.629000, 0.648000, 0.663000, 0.676000, 0.685000, 0.693000, 0.700000, 0.705000, 0.709000, 0.712000, 0.715000, 0.717000, 0.719000, 0.721000, 0.720000, 0.719000, 0.722000, 0.725000, 0.727000, 0.729000, 0.730000, 0.730000, 0.730000, 0.730000, 0.730000, 0.730000, 0.730000, 0.730000, 0.730000, 0.730000};


static const float D_ILLUM_S0[81] = {63.400, 64.600, 65.800, 80.300, 94.800, 99.800, 104.800, 105.350, 105.900, 101.350, 96.800, 105.350, 113.900, 119.750, 125.600, 125.550, 125.500, 123.400, 121.300, 121.300, 121.300, 117.400, 113.500, 113.300, 113.100, 111.950, 110.800, 108.650, 106.500, 107.650, 108.800, 107.050, 105.300, 104.850, 104.400, 102.200, 100.000, 98.000, 96.000, 95.550, 95.100, 92.100, 89.100, 89.800, 90.500, 90.400, 90.300, 89.350, 88.400, 86.200, 84.000, 84.550, 85.100, 83.500, 81.900, 82.250, 82.600, 83.750, 84.900, 83.100, 81.300, 76.600, 71.900, 73.100, 74.300, 75.350, 76.400, 69.850, 63.300, 67.500, 71.700, 74.350, 77.000, 71.100, 65.200, 56.450, 47.700, 58.150, 68.600, 66.800, 65.000};

static const float D_ILLUM_S1[81] = {38.500, 36.750, 35.000, 39.200, 43.400, 44.850, 46.300, 45.100, 43.900, 40.500, 37.100, 36.900, 36.700, 36.300, 35.900, 34.250, 32.600, 30.250, 27.900, 26.100, 24.300, 22.200, 20.100, 18.150, 16.200, 14.700, 13.200, 10.900, 8.600, 7.350, 6.100, 5.150, 4.200, 3.050, 1.900, 0.950, 0.000, -0.800, -1.600, -2.550, -3.500, -3.500, -3.500, -4.650, -5.800, -6.500, -7.200, -7.900, -8.600, -9.050, -9.500, -10.200, -10.900, -10.800, -10.700, -11.350, -12.000, -13.000, -14.000, -13.800, -13.600, -12.800, -12.000, -12.650, -13.300, -13.100, -12.900, -11.750, -10.600, -11.100, -11.600, -11.900, -12.200, -11.200, -10.200, -9.000, -7.800, -9.500, -11.200, -10.800, -10.400};

static const float D_ILLUM_S2[81] = {3.000, 2.100, 1.200, 0.050, -1.100, -0.800, -0.500, -0.600, -0.700, -0.950, -1.200, -1.900, -2.600, -2.750, -2.900, -2.850, -2.800, -2.700, -2.600, -2.600, -2.600, -2.200, -1.800, -1.650, -1.500, -1.400, -1.300, -1.250, -1.200, -1.100, -1.000, -0.750, -0.500, -0.400, -0.300, -0.150, 0.000, 0.100, 0.200, 0.350, 0.500, 1.300, 2.100, 2.650, 3.200, 3.650, 4.100, 4.400, 4.700, 4.900, 5.100, 5.900, 6.700, 7.000, 7.300, 7.950, 8.600, 9.200, 9.800, 10.000, 10.200, 9.250, 8.300, 8.950, 9.600, 9.050, 8.500, 7.750, 7.000, 7.300, 7.600, 7.800, 8.000, 7.350, 6.700, 5.950, 5.200, 6.300, 7.400, 7.100, 6.800};


// ===========================================================================
// Tabla de lineas de isotemperatura de Robertson (1968).
// Columnas: mired reciproco (1e6/K), u, v (CIE 1960 UCS), pendiente t = dv/du
// Fuente: Wyszecki & Stiles, "Color Science", Tabla 1(3.11)
// ===========================================================================
static const float ROBERTSON_TABLE[31][4] = {
    {0,   0.18006f, 0.26352f, -0.24341f},
    {10,  0.18066f, 0.26589f, -0.25479f},
    {20,  0.18133f, 0.26846f, -0.26876f},
    {30,  0.18208f, 0.27119f, -0.28539f},
    {40,  0.18293f, 0.27407f, -0.30470f},
    {50,  0.18388f, 0.27709f, -0.32675f},
    {60,  0.18494f, 0.28021f, -0.35156f},
    {70,  0.18611f, 0.28342f, -0.37915f},
    {80,  0.18740f, 0.28668f, -0.40955f},
    {90,  0.18880f, 0.28997f, -0.44278f},
    {100, 0.19032f, 0.29326f, -0.47888f},
    {125, 0.19462f, 0.30141f, -0.58204f},
    {150, 0.19962f, 0.30921f, -0.70471f},
    {175, 0.20525f, 0.31647f, -0.84901f},
    {200, 0.21142f, 0.32312f, -1.01820f},
    {225, 0.21807f, 0.32909f, -1.21680f},
    {250, 0.22511f, 0.33439f, -1.45120f},
    {275, 0.23247f, 0.33904f, -1.72980f},
    {300, 0.24010f, 0.34308f, -2.06370f},
    {325, 0.24792f, 0.34655f, -2.46810f},
    {350, 0.25591f, 0.34951f, -2.96410f},
    {375, 0.26400f, 0.35200f, -3.58140f},
    {400, 0.27218f, 0.35407f, -4.36330f},
    {425, 0.28039f, 0.35577f, -5.37620f},
    {450, 0.28863f, 0.35714f, -6.72620f},
    {475, 0.29685f, 0.35823f, -8.59550f},
    {500, 0.30505f, 0.35907f, -11.32400f},
    {525, 0.31320f, 0.35968f, -15.62800f},
    {550, 0.32129f, 0.36011f, -23.32500f},
    {575, 0.32931f, 0.36038f, -40.77000f},
    {600, 0.33724f, 0.36051f, -116.45000f},
};

// ===========================================================================
// Funciones basicas de colorimetria
// ===========================================================================

void spectrum_to_XYZ(const float spectrum[PSPECTRO_N], float &X, float &Y, float &Z) {
  X = 0; Y = 0; Z = 0;
  for (int i = 0; i < PSPECTRO_N; i++) {
    X += spectrum[i] * CMF_XBAR[i];
    Y += spectrum[i] * CMF_YBAR[i];
    Z += spectrum[i] * CMF_ZBAR[i];
  }
}

void XYZ_to_xy(float X, float Y, float Z, float &x, float &y) {
  float s = X + Y + Z;
  if (s <= 0) { x = 0; y = 0; return; }
  x = X / s;
  y = Y / s;
}

void XYZ_to_uv1960(float X, float Y, float Z, float &u, float &v) {
  float U = (2.0f / 3.0f) * X;
  float V = Y;
  float W = 0.5f * (-X + 3.0f * Y + Z);
  float s = U + V + W;
  if (s <= 0) { u = 0; v = 0; return; }
  u = U / s;
  v = V / s;
}

float uv_to_CCT_Robertson(float u, float v, float &Duv) {
  float du[31], dv[31], dt[31];
  for (int i = 0; i < 31; i++) {
    float t = ROBERTSON_TABLE[i][3];
    float length = sqrtf(1.0f + t * t);
    du[i] = 1.0f / length;
    dv[i] = t / length;
  }

  int found_i = -1;
  for (int i = 1; i < 31; i++) {
    float u_i = ROBERTSON_TABLE[i][1];
    float v_i = ROBERTSON_TABLE[i][2];
    float uu = u - u_i;
    float vv = v - v_i;
    dt[i] = -uu * dv[i] + vv * du[i];
    if (dt[i] <= 0) { found_i = i; break; }
  }
  if (found_i < 0) found_i = 30;
  int i = found_i;

  float dt_current = -fminf(dt[i], 0.0f);
  float dt_previous = dt[i - 1];
  float f = (i == 1) ? 0.0f : dt_current / (dt_previous + dt_current);

  float r = ROBERTSON_TABLE[i - 1][0] * f + ROBERTSON_TABLE[i][0] * (1.0f - f);
  float T = 1.0e6f / r;

  float u_interp = ROBERTSON_TABLE[i - 1][1] * f + ROBERTSON_TABLE[i][1] * (1.0f - f);
  float v_interp = ROBERTSON_TABLE[i - 1][2] * f + ROBERTSON_TABLE[i][2] * (1.0f - f);
  float du_i = du[i] * (1.0f - f) + du[i - 1] * f;
  float dv_i = dv[i] * (1.0f - f) + dv[i - 1] * f;
  float L = sqrtf(du_i * du_i + dv_i * dv_i);
  du_i /= L;
  dv_i /= L;

  float uu = u - u_interp;
  float vv = v - v_interp;
  Duv = -(uu * du_i + vv * dv_i);

  return T;
}

// ===========================================================================
// Generacion del iluminante de referencia (para el calculo de CRI)
// ===========================================================================

// Ley de Planck. lambda_m en metros, T en kelvin.
static float planck_radiance(float lambda_m, float T) {
  const float c1 = 3.741771e-16f;
  const float c2 = 1.4388e-2f;
  float d = 1.0f / (expf(c2 / (lambda_m * T)) - 1.0f);
  return (c1 * powf(lambda_m, -5.0f) / (float)M_PI) * d;
}

static void blackbody_spectrum(float T, float out[PSPECTRO_N]) {
  for (int i = 0; i < PSPECTRO_N; i++) {
    float wl_nm = 380.0f + 5.0f * i;
    out[i] = planck_radiance(wl_nm * 1e-9f, T);
  }
}

static float daylight_locus(float x) {
  return -3.000f * x * x + 2.870f * x - 0.275f;
}

static void CCT_to_xy_CIE_D(float CCT, float &x, float &y) {
  float CCT2 = CCT * CCT;
  float CCT3 = CCT2 * CCT;
  if (CCT <= 7000.0f) {
    x = -4.607e9f / CCT3 + 2.9678e6f / CCT2 + 0.09911e3f / CCT + 0.244063f;
  } else {
    x = -2.0064e9f / CCT3 + 1.9018e6f / CCT2 + 0.24748e3f / CCT + 0.23704f;
  }
  y = daylight_locus(x);
}

static void d_illuminant_spectrum(float CCT, float out[PSPECTRO_N]) {
  float x, y;
  CCT_to_xy_CIE_D(CCT, x, y);
  float M = 0.0241f + 0.2562f * x - 0.7341f * y;
  float M1 = (-1.3515f - 1.7703f * x + 5.9114f * y) / M;
  float M2 = (0.0300f - 31.4424f * x + 30.0717f * y) / M;
  // redondeo a 3 decimales, segun recomendacion CIE 015:2004
  M1 = roundf(M1 * 1000.0f) / 1000.0f;
  M2 = roundf(M2 * 1000.0f) / 1000.0f;
  for (int i = 0; i < PSPECTRO_N; i++) {
    out[i] = D_ILLUM_S0[i] + M1 * D_ILLUM_S1[i] + M2 * D_ILLUM_S2[i];
  }
}

// ===========================================================================
// CRI (CIE 13.3-1995): colorimetria de las 8 muestras de color (TCS01-08)
// bajo un iluminante S, mas adaptacion cromatica y espacio CIE 1964 U*V*W*
// ===========================================================================

static const float *TCS_TABLE[8] = {
  TCS_TCS01, TCS_TCS02, TCS_TCS03, TCS_TCS04,
  TCS_TCS05, TCS_TCS06, TCS_TCS07, TCS_TCS08
};

static inline float c_term(float u, float v) { return (4.0f - u - 10.0f * v) / v; }
static inline float d_term(float u, float v) { return (1.708f * v + 0.404f - 1.481f * u) / v; }

// Calcula (U*,V*,W*) de las 8 muestras bajo el iluminante S.
// chromatic_adaptation: true para el lado "test" (adapta al punto blanco
// de referencia), false para el lado "referencia" (no necesita adaptarse
// a si mismo).
static void tcs_colorimetry(const float S[PSPECTRO_N], const float S_ref[PSPECTRO_N],
                             bool chromatic_adaptation, float UVW_out[8][3]) {
  float Xt, Yt, Zt;
  spectrum_to_XYZ(S, Xt, Yt, Zt);
  float ut, vt;
  XYZ_to_uv1960(Xt, Yt, Zt, ut, vt);

  float Xr, Yr, Zr;
  spectrum_to_XYZ(S_ref, Xr, Yr, Zr);
  float ur, vr;
  XYZ_to_uv1960(Xr, Yr, Zr, ur, vr);

  float sum_ybar_S = 0;
  for (int i = 0; i < PSPECTRO_N; i++) sum_ybar_S += S[i] * CMF_YBAR[i];

  float ct = 0, dt = 0, cr = 0, dr = 0;
  if (chromatic_adaptation) {
    ct = c_term(ut, vt); dt = d_term(ut, vt);
    cr = c_term(ur, vr); dr = d_term(ur, vr);
  }

  for (int k = 0; k < 8; k++) {
    const float *R = TCS_TABLE[k];
    float Xtcs = 0, Ytcs = 0, Ztcs = 0;
    for (int i = 0; i < PSPECTRO_N; i++) {
      float w = R[i] * S[i];
      Xtcs += w * CMF_XBAR[i];
      Ytcs += w * CMF_YBAR[i];
      Ztcs += w * CMF_ZBAR[i];
    }
    float u_tcs, v_tcs;
    XYZ_to_uv1960(Xtcs, Ytcs, Ztcs, u_tcs, v_tcs);
    float Y_norm = 100.0f * Ytcs / sum_ybar_S;

    if (chromatic_adaptation) {
      float ctcs = c_term(u_tcs, v_tcs);
      float dtcs = d_term(u_tcs, v_tcs);
      float cr_ct = cr / ct;
      float dr_dt = dr / dt;
      float denom = 16.518f + 1.481f * cr_ct * ctcs - dr_dt * dtcs;
      u_tcs = (10.872f + 0.404f * cr_ct * ctcs - 4.0f * dr_dt * dtcs) / denom;
      v_tcs = 5.52f / denom;
    }

    float W = 25.0f * cbrtf(Y_norm) - 17.0f;
    float U = 13.0f * W * (u_tcs - ur);
    float V = 13.0f * W * (v_tcs - vr);
    UVW_out[k][0] = U;
    UVW_out[k][1] = V;
    UVW_out[k][2] = W;
  }
}

// ===========================================================================
// Funcion principal
// ===========================================================================

ColorimetryResult calcular_colorimetria(const float spectrum[PSPECTRO_N]) {
  ColorimetryResult r;

  spectrum_to_XYZ(spectrum, r.X, r.Y, r.Z);
  XYZ_to_xy(r.X, r.Y, r.Z, r.x, r.y);
  XYZ_to_uv1960(r.X, r.Y, r.Z, r.u, r.v);
  r.CCT = uv_to_CCT_Robertson(r.u, r.v, r.Duv);
  r.cct_reliable = fabsf(r.Duv) <= 0.05f;

  // --- Construir el iluminante de referencia para el CRI ---
  float S_ref[PSPECTRO_N];
  if (r.CCT < 5000.0f) {
    blackbody_spectrum(r.CCT, S_ref);
  } else {
    d_illuminant_spectrum(r.CCT, S_ref);
  }

  // --- Colorimetria de las 8 muestras bajo la fuente de prueba y la referencia ---
  float UVW_test[8][3];
  float UVW_ref[8][3];
  tcs_colorimetry(spectrum, S_ref, true, UVW_test);
  tcs_colorimetry(S_ref, S_ref, false, UVW_ref);

  float sum_Ra = 0;
  for (int k = 0; k < 8; k++) {
    float dU = UVW_test[k][0] - UVW_ref[k][0];
    float dV = UVW_test[k][1] - UVW_ref[k][1];
    float dW = UVW_test[k][2] - UVW_ref[k][2];
    float dE = sqrtf(dU * dU + dV * dV + dW * dW);
    r.Ri[k] = 100.0f - 4.6f * dE;
    sum_Ra += r.Ri[k];
  }
  r.Ra = sum_Ra / 8.0f;

  return r;
}
